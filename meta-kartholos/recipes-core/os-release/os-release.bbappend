OS_RELEASE_FIELDS:append = " HOME_URL"
HOME_URL = "https://kartholos.org"

ID = "kartholos"
NAME = "KartholOS"
PRETTY_NAME = "KartholOS Linux"
VERSION = "1.0.0 (Scarthgap)"
VERSION_ID = "1.0.0"
